# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC
  c include: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_pwr.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c croutine.c queue.c timers.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c freertos.c stm32f0xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
